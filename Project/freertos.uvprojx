# Keil uVision project freertos.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: freertos +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\User;..\STM32F10x_FWLib\src;..\CORE;..\Project;..\STM32F10x_FWLib\inc;..\FreeRTOS\FreeRTOS src;..\FreeRTOS\FreeRTOS port\MemMang;..\FreeRTOS\FreeRTOS port\RVDS\ARM_CM3;..\FreeRTOS\include;..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\LED;..\FreeRTOS\include;..\FreeRTOS\FreeRTOS src;..\FreeRTOS\FreeRTOS port;..\HARDWARE;..\HARDWARE\DHT11;..\HARDWARE\Relays;..\HARDWARE\soil_sensor;..\Connection;..\HARDWARE\GY-30;..\HARDWARE\sgp30
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group core
    ../User/: stm32f10x_it.c
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group User
    ../User/: system_stm32f10x.c main.c FreeRTOSConfig.h
  group FreeRTOS/src
    ../FreeRTOS/FreeRTOS src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/FreeRTOS port/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/FreeRTOS port/MemMang/: heap_4.c
  group sys
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group hardware
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/Relays/: relays.c
    ../HARDWARE/soil_sensor/: YL-69.c
    ../HARDWARE/sgp30/: sgp30.c
    ../HARDWARE/GY-30/: gy30.c
  group Connection
    ../Connection/: cJSON.c esp8266.c MqttKit.c onenet.c
